#pragma once
namespace Ui {
inline String tr(const String& label){if(!chinese)return label;
 if(label=="Sun")return "周日";
 if(label=="Mon")return "周一";
 if(label=="Tue")return "周二";
 if(label=="Wed")return "周三";
 if(label=="Thu")return "周四";
 if(label=="Fri")return "周五";
 if(label=="Sat")return "周六";
 if(label==" drives")return " 块硬盘";
 if(label==" volumes")return " 个卷";
 if(label=="d ")return "天 ";
 if(label=="h")return "小时";
 if(label==" OK ")return " 正常 ";
 if(label=="s ago")return " 秒前";
 if(label==" WAIT")return " 等待";
 if(label=="DESKTOP CLOCK")return "桌面时钟";
 if(label=="PHOTO ALBUM")return "相册";
 if(label=="Upload photos in management")return "请在管理页上传照片";
 if(label=="Crop / zoom / rotate")return "裁剪、缩放、旋转";
 if(label=="DISKS / HEALTH")return "硬盘健康";
 if(label=="ALL VOLUMES")return "所有存储卷";
 if(label=="Discovering disks...")return "正在发现硬盘";
 if(label=="Discovering volumes...")return "正在发现存储卷";
 if(label=="NETWORK")return "网络";
 if(label=="RECEIVE")return "接收";
 if(label=="SEND")return "发送";
 if(label=="CPU / MEMORY")return "处理器与内存";
 if(label=="CPU usage")return "处理器占用";
 if(label=="Memory usage")return "内存占用";
 if(label=="Memory")return "内存";
 if(label=="Used")return "已用";
 if(label=="Total")return "总计";
 if(label=="Free")return "可用";
 if(label=="RAM excludes buffers/cache")return "内存不含缓存";
 if(label=="DEVICE / STATUS")return "设备状态";
 if(label=="5 taps: management QR")return "五击进入管理";
 if(label=="WEATHER / CLOCK")return "天气时钟";
 if(label=="Weather loading...")return "正在获取天气";
 if(label=="Waiting for weather")return "等待天气数据";
 if(label=="Waiting for samples")return "等待采样";
 if(label=="TOUCH")return "触摸";
 if(label=="NAS TEMP")return "温度";
 if(label=="OK")return "正常";
 if(label=="CHECK")return "检查";
 if(label=="ALARM")return "闹钟";
 if(label=="OFF")return "关闭";
 if(label=="RINGING: tap snooze / 3x stop")return "单击贪睡，三击停止";
 if(label=="Stopped for today")return "今天已停止";
 if(label=="Scheduled alarm")return "定时闹钟";
 if(label=="CONNECTING")return "正在联网";
 if(label=="Joining Wi-Fi...")return "正在连接无线网络";
 if(label=="RESET DEVICE?")return "重置设备？";
 if(label=="3 taps to confirm")return "连续三击确认重置";
 if(label=="Erases settings/photos")return "清除全部配置与照片";
 if(label=="Cancels after 10s")return "十秒后自动取消";
 if(label=="WI-FI SETUP")return "无线配网";
 if(label=="MANAGEMENT")return "设备管理";
 if(label=="Scan to open settings")return "扫码打开设置";
 if(label=="Touch to return")return "单击返回";
 if(label=="Open 192.168.4.1")return "打开 192.168.4.1";
 if(label=="Connecting WiFi...")return "正在连接无线网络";
 if(label=="6 taps: Wi-Fi setup")return "六击重新配网";
 if(label=="RESET SETTINGS?")return "重置配置？";
 if(label=="Tap 3 times to confirm")return "连续三击确认重置";
 if(label=="Expires in 10 seconds")return "十秒后自动取消";
 if(label=="All settings and photos will be deleted")return "配置与照片将清除";
 if(label=="Double tap: more")return "双击查看更多";
 if(label=="Time syncing")return "等待校时";
 if(label=="Synology NAS")return "群晖 NAS";
 if(label=="China Weather / UTC+8")return "中国天气网";
 if(label.startsWith("Disk"))return String("硬盘")+label.substring(4,label.length());
 if(label.startsWith("TV   "))return String("小电视 ")+label.substring(5,label.length());
 if(label.startsWith("IF: "))return String("网口 ")+label.substring(4,label.length());
 if(label.startsWith("Up   "))return String("运行 ")+label.substring(5,label.length());
 if(label.startsWith("RH "))return String("湿度 ")+label.substring(3,label.length());
 if(label.startsWith("AQI "))return String("空气 ")+label.substring(4,label.length());
 if(label.startsWith("Snooze "))return String("贪睡 ")+label.substring(7,label.length());
 if(label.startsWith("Key: "))return String("密码 ")+label.substring(5,label.length());
 return label;
}
}
